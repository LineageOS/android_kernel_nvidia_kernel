## arch/arm64/configs/smaug_variant_defconfig
```kconfig
CONFIG_BUILD_ARM64_APPENDED_DTB_IMAGE=y
CONFIG_BUILD_ARM64_APPENDED_DTB_IMAGE_NAMES="tegra210-smaug"
```
